# Keil uVision project classwork3_3_10_2.uvproj, settings and files
target classwork3_3_10_2 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: classwork3_3_10_2 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\..\..\..\..\..\..\..\..\Soft\tool\KeilC51v9.01a\C51\INC
  group SRC
    src/: classwork.asm

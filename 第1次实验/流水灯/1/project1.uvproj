# Keil uVision project project1.uvproj, settings and files
target 目标 1 (MCS-51)
  device: SST89V554RC SST
  cpu: IRAM(0-0xFF) IROM(0-0x7FFF) CLOCK(25000000)
  output: project1 +hex
  c flags: Optimize=8 SizeSpeed=1
  group 源组 1
    ./: STARTUP.A51 project1.c

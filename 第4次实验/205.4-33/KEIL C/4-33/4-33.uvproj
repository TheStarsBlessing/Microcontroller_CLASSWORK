# Keil uVision project 4-33.uvproj, settings and files
target 4-33 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: 4-33 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: inc;..\..\..\..\..\..\..\..\..\..\..\Soft\tool\KeilC51v9.01a\C51\INC
  group SRC
    src/: main.c

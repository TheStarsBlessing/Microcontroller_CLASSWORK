# Keil uVision project 89c52_KEIL5-quickstart.uvproj, settings and files
target 89c52_KEIL5-quickstart (MCS-51)
  device: AT89C52 Atmel
  output: 89c52_KEIL5-quickstart +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: inc;..\..\..\..\..\..\..\..\..\Soft\tool\KeilC51v9.01a\C51\INC
  group SRC
    src/: main.c

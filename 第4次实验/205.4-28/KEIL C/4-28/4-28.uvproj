# Keil uVision project 4-28.uvproj, settings and files
target 4-28 (MCS-51)
  device: AT89C52 Atmel
  output: 4-28 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: inc;..\..\..\..\..\..\..\..\..\..\..\Soft\tool\KeilC51v9.01a\C51\INC
  group SRC
    src/: main.c
